# Keil uVision project BH1750.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\LED;..\User\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STASTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/USART/: usart.c
    ../User/SYSTICK/: systick.c
    ../User/OLED/: OLED.c OLED.h OLED_Font.h
    ../User/Encoder/: Encoder.c
    ../User/step/: step.c step.h
    ../User/I2C_BH1750/: i2cA_bh1750A.c i2cA_bh1750A_gpio.c i2cB_bh1750B.c i2cB_bh1750B_gpio.c i2cC_bh1750C.c i2cC_bh1750C_gpio.c i2cD_bh1750D.c i2cD_bh1750D_gpio.c i2cE_bh1750E.c i2cE_bh1750E_gpio.c i2cF_bh1750F.c i2cF_bh1750F_gpio.c i2cG_bh1750G.c i2cG_bh1750G_gpio.c i2cH_bh1750H.c i2cH_bh1750H_gpio.c
    ../User/jdq/: jdq.c jdq.h
  group DOC
    ../Doc/: readme.txt
